options:
  parameters:
    author: crypie86
    generate_options: qt_gui
    id: pythonblocksandbox
    output_language: python
    title: pythonblocksandbox
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: frequency
    start: '88000000'
    step: '200000'
    stop: '1008000000'
    value: '91000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import matlab.engine
      import pmt
      import os
      import time

      eng = matlab.engine.start_matlab()
      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Runs matlab executive function every time it registers that [filename] has been modified and spits its output out as a message\nOne caveat is that [filename] needs to already exist in the present directory, otherwise there'll be an error thrown saying that the file doesn't exist."""

          def __init__(self, filename = 'noise1kcos.txt'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Call MATLAB executive(filename)',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
                  
          
              )
              self.filename = filename
              self.time1 = os.path.getmtime(self.filename)
              self.message_port_register_out(pmt.intern('chosen pattern'))
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              

          def work(self, input_items, output_items):
              self.time2 = os.path.getmtime(self.filename)
              if(self.time2 != self.time1):
                  time.sleep(1)
                  self.time1 = self.time2
                  print('aya, something changed!') #i think the reason why this goes through twice is because its catching on to when the file's still being written, although im not sure if dealing with that is even necessary
                  whee = pmt.to_pmt(int(eng.executive(self.filename)))
                  self.message_port_pub(pmt.intern('chosen pattern'), whee)
              
              output_items[0][:] = 1
              return len(output_items[0])
    filename: '''bababooey.bin'''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import subprocess

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Block to loop [script_name (the spectrum sampling block)] every [delay (5)] seconds and passing in [script_args]"""

          def __init__(self, script_name='sandbox.py', delay = 5, script_args = '--filename ./noise1kcos.txt'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Loop Script',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.script_name = './' + script_name
              self.delay = delay
              self.args = script_args
              self.cmdlstr = self.script_name + ' ' + self.args
              self.cmdlist = self.cmdlstr.split()

          def work(self, input_items, output_items):
              print('running the script', self.script_name, 'with args', self.args)
              subprocess.run(self.cmdlist)
              print('finished')
              time.sleep(self.delay)
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    delay: '5'
    script_args: '''--filename ./noise1kcos.txt'''
    script_name: '''sandbox.py'''
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message Reader',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.message_port_register_in(pmt.intern('msgin'))
              self.set_msg_handler(pmt.intern('msgin'), self.handle_msg)
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.thingy = 1
              
          def handle_msg(self, msg):
              self.thingy = pmt.to_python(msg)
          def work(self, input_items, output_items):
              print(self.thingy)
              output_items[0][:] = input_items[0]
              return len(output_items[0])
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: spectrum_sampler_v2_0
  id: spectrum_sampler_v2
  parameters:
    fftlen: '64'
    filename: ./copytest2.bin
    numsnaps: '4'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    dev_addr: '"addr=192.168.10.2"'
    gain0: '0'
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_1, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_null_source_0, '0', epy_block_0, '0']
- [blocks_null_source_0, '0', epy_block_2, '0']
- [blocks_null_source_1, '0', epy_block_1, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_1, '0', blocks_null_sink_1, '0']
- [blocks_throttle_1, '0', spectrum_sampler_v2_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [epy_block_0, chosen pattern, epy_block_2, msgin]
- [epy_block_1, '0', blocks_throttle_1, '0']
- [epy_block_2, '0', blocks_null_sink_2, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', spectrum_sampler_v2_0, '0']

metadata:
  file_format: 1
