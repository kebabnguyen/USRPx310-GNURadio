options:
  parameters:
    author: crypie86
    generate_options: qt_gui
    id: pythonblocksandbox
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import matlab.engine
      import pmt

      eng = matlab.engine.start_matlab()
      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, filename = 'readingcenter91M64bins.txt'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Call MATLAB executive(filename)',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
                  
          
              )
              self.filename = filename
              self.message_port_register_out(pmt.intern('chosen bins'))
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              

          def work(self, input_items, output_items):
              whee = pmt.to_pmt(eng.executive(self.filename))
              self.message_port_pub(pmt.intern('chosen bins'), whee)
              output_items[0][:] = 1
              return len(output_items[0])
    filename: '''noise1kcos.txt'''
  states: {}

connections:
- [blocks_null_source_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [epy_block_0, chosen bins, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-38-g72311c07
