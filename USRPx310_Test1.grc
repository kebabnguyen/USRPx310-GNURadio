options:
  parameters:
    generate_options: qt_gui
    id: USRPx310_Test1
    output_language: python
    title: USRPx310-Test1
  states: {}

blocks:
- name: asdf
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '70000000'
    step: '200000'
    stop: '6000000000'
    value: '102100000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: '192000'
    step: '1000'
    stop: '56000000'
    value: '3840000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: asdf
    fftsize: '1024'
    name: '"Spectrum Analyzer"'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: asdf
    dc_offs_enb0: '""'
    dev_addr: addr=192.168.10.2
    gain0: rf_gain
    iq_imbal_enb0: '""'
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
