options:
  parameters:
    generate_options: qt_gui
    id: CHIRPgen_sim
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: B
  id: variable
  parameters:
    value: BT//T
  states: {}
- name: BT
  id: variable
  parameters:
    value: '50'
  states: {}
- name: N
  id: variable
  parameters:
    value: BT*OVS
  states: {}
- name: OVS
  id: variable
  parameters:
    value: '10'
  states: {}
- name: T
  id: variable
  parameters:
    value: '0.00005'
  states: {}
- name: fs
  id: variable
  parameters:
    value: B*OVS
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /nfs/users/j149q328/Documents/CHIRPgen_re.txt
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /nfs/users/j149q328/Documents/CHIRPgen_im.txt
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: 2*N-1
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: N
    srate: fs
    type: complex
    ymax: '0.05'
    ymin: '-0.05'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_1, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
