options:
  parameters:
    author: koovin
    description: takes in hardware radio source to read numsnaps samples of the spectrum divvied up into fftlen bins, and then spits it out into filename (really the filepath).
    generate_options: hb
    id: spectrum_sampler
    output_language: python
    title: Spectrum Sampler Block
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftlen
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: float
    vlen: fftlen
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: numsnaps
    type: float
    vlen: fftlen
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: fftlen
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftlen
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftlen
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftlen)
  states: {}
- name: fftlen
  id: parameter
  parameters:
    label: length_fft
    type: intx
    value: '64'
  states: {}
- name: filename
  id: parameter
  parameters:
    label: output_filename
    type: str
    value: ./91M64bins.txt
  states: {}
- name: numsnaps
  id: parameter
  parameters:
    label: num_fftsamples
    type: intx
    value: '4'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: radio
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: thesauce
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: thesauce
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_head_0_0, '0', blocks_file_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_head_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
