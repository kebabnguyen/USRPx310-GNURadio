options:
  parameters:
    generate_options: qt_gui
    id: junk
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_length_tag_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter_rx
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=length_tag_key, frame_len_tag_key=frame_length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26,-21)) + list(range(-20,-9)) + list(range(11,21)) + list(range(22,28)), list(range(-9,-7)) + list(range(-6,0)) + list(range(1,7)) + list(range(8,10)) + list(range(11,21)) + list(range(22,28)), list(range(-26,-21)) + list(range(-20,-9)), list(range(-9,-7)) + list(range(-6,0)) + list(range(1,7)) + list(range(8,10)), list(range(11,21)) + list(range(22,28)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sc
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '2'
    value: '0'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: thold
  id: variable_qtgui_range
  parameters:
    label: Threshold
    min_len: '1000'
    rangeType: int
    start: '0'
    step: '1'
    stop: '800'
    value: '380'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /nfs/users/j149q328/Documents/ass.txt
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("beep")
    period: '1000'
  states: {}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: '500'
    max_iter: '1000'
    scale: '0.02'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: length_tag_key
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: fft_len//4
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: frame_length_tag_key
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: frame_length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: frame_length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_header
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: frame_length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {state: disabled}
- name: digital_ofdm_serializer_vcc_payload
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: frame_length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: length_tag_key
    symbols_skipped: '1'
  states: {state: disabled}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter_rx
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, key = "sc_tag_key", packet_key = "packet_len", vlen = 64):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='OFDMA Controller: vector',   # will show up in GRC
                  in_sig=[(np.complex64,vlen)],
                  out_sig=[(np.complex64,vlen)]
              )

              self.key = key;
              #self.pattern = pattern;
              self.packet_key = packet_key;
              
              self.selectPortName = 'msg2'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)
              self.pattern = 1
              
          def handle_msg(self, msg):
          	self.pattern = pmt.to_python(msg)
          	
          def work(self, input_items, output_items):
              pkey = pmt.intern(self.key)
              ppattern = pmt.to_pmt(self.pattern)
              ppacket = pmt.to_pmt(self.packet_key)
              for i, sample in enumerate(input_items[0]):
                  t = self.nitems_written(0) + i
                  #this seems like a "hacky" way of doing this, but it works and I can't find any other way
                  tags = self.get_tags_in_range(0, t, t+1,ppacket)
                  if (len(tags) != 0):
                      self.add_item_tag(0, self.nitems_written(0)+i, pkey, ppattern)
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    key: '''sc_tag_key'''
    packet_key: length_tag_key
    vlen: fft_len
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, key = "sc_tag_key", packet_key = "packet_len", vlen = 64):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='OFDMA Controller: vector',   # will show up in GRC
                  in_sig=[(np.complex64,vlen)],
                  out_sig=[(np.complex64,vlen)]
              )

              self.key = key;
              #self.pattern = pattern;
              self.packet_key = packet_key;
              
              self.selectPortName = 'msg2'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)
              self.pattern = 1
              
          def handle_msg(self, msg):
          	self.pattern = pmt.to_python(msg)
          	
          def work(self, input_items, output_items):
              pkey = pmt.intern(self.key)
              ppattern = pmt.to_pmt(self.pattern)
              ppacket = pmt.to_pmt(self.packet_key)
              for i, sample in enumerate(input_items[0]):
                  t = self.nitems_written(0) + i
                  #this seems like a "hacky" way of doing this, but it works and I can't find any other way
                  tags = self.get_tags_in_range(0, t, t+1,ppacket)
                  if (len(tags) != 0):
                      self.add_item_tag(0, self.nitems_written(0)+i, pkey, ppattern)
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    key: '''sc_tag_key'''
    packet_key: length_tag_key
    vlen: fft_len
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):

          def __init__(self, vlen = 64, thold = 500):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Power Decision Block 3',
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              self.vlen = vlen
              self.thold = thold
              self.message_port_register_out(pmt.intern("pattern_out"))

          def work(self, input_items, output_items):
              inp = np.array(input_items)
              inp = inp[0,:]
              sc_lut = np.array([[-26, -25, -24, -23, -22, -20, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10], [-9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 9], [11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 22, 23, 24, 25, 26, 27]]) #-32 to +31
              #this is a test program where the subcarrier patterns and dimensions will be hard-coded
              i = -1
              run = True
              while (run and i < 2):
              	i = i+1
              	run = False
              	for j in range(0, 15):
              		if inp[0][(sc_lut[i][j])+32] < self.thold: #the difference here (vs power decision block 2) is we WANT to match the pattern
              			run = True
              # we found a successful pattern if run is false, otherwise none of the patterns worked and output a -1 (sus condition)
              if run:
              	i = -1
              self.message_port_pub(pmt.intern("pattern_out"), pmt.to_pmt(i))
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    thold: thold
    vlen: fft_len
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n\n    def __init__(self, packet_key = \"packet_len\"):  # only default arguments here\n        gr.sync_block.__init__(\n            self,\n            name='Pattern Retriever',   # will show up in GRC\n            in_sig=[np.int8],\n            out_sig=[np.int8]\n        )\n        self.message_port_register_out(pmt.intern('msg_out'))\n        self.packet_key = packet_key;\n\n    def work(self, input_items, output_items):\n    \tcounter = 0\n    \tppacket = pmt.to_pmt(self.packet_key)\n    \tfor i, sample in enumerate(input_items[0]):\n    \t\tt = self.nitems_written(0) + i\n    \t\ttags = self.get_tags_in_range(0,t,t+1,ppacket)\n    \t\t#output_items[0][i] = input_items[0][i]\n    \t\t#if (len(tags) != 0): # if there is a packet length tag\n    \t\tif i % 31 == 0:\n    \t\t\toutput_items[0][i] = input_items[0][i]\n    \t\t\tself.message_port_pub(pmt.intern('msg_out'), pmt.intern(str(input_items[0][i])))\n    \t\telse:\n    \t\t\toutput_items[0][i] = input_items[0][i]\n    \treturn len(output_items[0])\n\n\t\n"
    packet_key: '''packet_len'''
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.digital.utils import tagged_streams
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '1'
    fft_size: fft_len
    frame_rate: '1000'
    ref_scale: '0.00001'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: fft_len
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: sonny_ofdma_ofdma_rx_0
  id: sonny_ofdma_ofdma_rx
  parameters:
    carr_offset_key: '""'
    fft_len: fft_len
    input_is_shifted: 'True'
    len_tag_key: frame_length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: length_tag_key
    sc_tag_key: '"sc_tag_key"'
    symbols_skipped: '0'
  states: {}
- name: sonny_ofdma_ofdma_rx_0_0
  id: sonny_ofdma_ofdma_rx
  parameters:
    carr_offset_key: '""'
    fft_len: fft_len
    input_is_shifted: 'True'
    len_tag_key: frame_length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: '""'
    sc_tag_key: '"sc_tag_key"'
    symbols_skipped: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Payload Stream
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_message_strobe_0, strobe, blocks_message_debug_0_0, print]
- [blocks_moving_average_xx_1_0, '0', epy_block_0_0_1, '0']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', epy_block_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_constellation_decoder_cb_1, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_0_1, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_1_0, '0']
- [digital_ofdm_chanest_vcvc_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_header, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', epy_block_0_0_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', digital_ofdm_serializer_vcc_payload, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', epy_block_0_0, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_constellation_decoder_cb_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', digital_constellation_decoder_cb_1, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [digital_packet_headerparser_b_0, header_data, digital_header_payload_demux_0, header_data]
- [epy_block_0_0, '0', sonny_ofdma_ofdma_rx_0, '0']
- [epy_block_0_0_0, '0', sonny_ofdma_ofdma_rx_0_0, '0']
- [epy_block_0_0_1, '0', qtgui_vector_sink_f_0_0, '0']
- [epy_block_0_0_1, pattern_out, blocks_message_strobe_0, set_msg]
- [epy_block_0_0_1, pattern_out, epy_block_0_0, msg2]
- [epy_block_0_0_1, pattern_out, epy_block_0_0_0, msg2]
- [epy_block_1, '0', blocks_file_sink_0_0, '0']
- [epy_block_1, msg_out, blocks_message_debug_0, print]
- [fft_vxx_0_0, '0', digital_ofdm_chanest_vcvc_0, '0']
- [fft_vxx_1, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- [logpwrfft_x_0, '0', blocks_moving_average_xx_1_0, '0']
- [sonny_ofdma_ofdma_rx_0, '0', digital_constellation_decoder_cb_1, '0']
- [sonny_ofdma_ofdma_rx_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [uhd_usrp_source_0, '0', logpwrfft_x_0, '0']
- [virtual_source_0_1, '0', fft_vxx_0_0, '0']
- [virtual_source_1_0, '0', fft_vxx_1, '0']

metadata:
  file_format: 1
