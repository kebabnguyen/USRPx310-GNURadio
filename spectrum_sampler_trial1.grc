options:
  parameters:
    generate_options: no_gui
    id: spectrum_sampler_pjfft
    output_language: python
    run_options: run
    title: spectrum_sampler_pjfft
  states: {}

blocks:
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftlen
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: float
    vlen: fftlen
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: numsnaps
    type: float
    vlen: fftlen
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: fftlen
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftlen
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftlen
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftlen)
  states: {}
- name: fftlen
  id: parameter
  parameters:
    label: length_fft
    type: intx
    value: '64'
  states: {}
- name: filename
  id: parameter
  parameters:
    label: output_filename
    type: str
    value: ./readingcenter91M64bins.txt
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    type: eng_float
    value: '91000000'
  states: {}
- name: numsnaps
  id: parameter
  parameters:
    label: num_fftsamples
    type: intx
    value: '4'
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: rf_gain
    type: eng_float
    value: '50'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sample rate
    type: intx
    value: '1920000'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    clock_rate: 200e6
    dev_addr: addr=192.168.10.2
    gain0: rf_gain
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: thesauce
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: thesauce
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_head_0_0, '0', blocks_file_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_head_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-38-g72311c07
