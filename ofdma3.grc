options:
  parameters:
    generate_options: qt_gui
    id: junk
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: frame_length_tag_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: rf gain
    start: '-10'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter_rx
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=length_tag_key, frame_len_tag_key=frame_length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26,-21)) + list(range(-20,-9)), list(range(-9,-7)) + list(range(-6,0)) + list(range(1,7)) + list(range(8,10)), list(range(11,21)) + list(range(22,28)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: sc
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '2'
    value: '0'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: thold
  id: variable_qtgui_range
  parameters:
    label: Threshold
    min_len: '1000'
    rangeType: int
    start: '0'
    step: '1'
    stop: '1000'
    value: '500'
  states: {}
- name: thold_0
  id: variable_qtgui_range
  parameters:
    label: Threshold
    min_len: '1000'
    rangeType: int
    start: '0'
    step: '1'
    stop: '800'
    value: '380'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/a754f585/Documents/e.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("beep")
    period: '1000'
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: '10'
    scale: '0.3'
    type: float
    vlen: fft_len
  states: {state: disabled}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: '500'
    max_iter: '1000'
    scale: '0.02'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: packet_len
    name: packet length
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {state: disabled}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_formatter_rx.base()
    len_tag_key: length_tag_key
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, key = "sc_tag_key", pattern = 0, packet_key = "packet_len"):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='OFDMA Controller Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.key = key;
              self.pattern = pattern;
              self.packet_key = packet_key;

          def work(self, input_items, output_items):
              pkey = pmt.intern(self.key)
              ppattern = pmt.to_pmt(self.pattern)
              ppacket = pmt.to_pmt(self.packet_key)
              for i, sample in enumerate(input_items[0]):
                  t = self.nitems_written(0) + i
                  #this seems like a "hacky" way of doing this, but it works and I can't find any other way
                  tags = self.get_tags_in_range(0, t, t+1,ppacket)
                  if (len(tags) != 0):
                      self.add_item_tag(0, self.nitems_written(0)+i, pkey, ppattern)
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    key: '''sc_tag_key'''
    packet_key: '''packet_len'''
    pattern: sc
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, vlen = 64, thold = 500):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Power Decision Block',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              self.vlen = vlen
              self.thold = thold
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              #output_items[0][:] = input_items[0][:]
              #fuck you Python
              inp = np.array(input_items)
              inp = inp[0,:]
              oup = inp
              for i in range(self.vlen):
                  if inp[0][i] > self.thold:
                      oup[0][i] = 1000
                  else:
                      oup[0][i] = 0
              output_items[0][:] = oup[0][:]
              return len(output_items[0])
    thold: thold
    vlen: fft_len
  states: {state: disabled}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):

          def __init__(self, vlen = 64, thold = 500):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Power Decision Block 3',
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              self.vlen = vlen
              self.thold = thold
              self.message_port_register_out(pmt.intern("pattern_out"))

          def work(self, input_items, output_items):
              inp = np.array(input_items)
              inp = inp[0,:]
              sc_lut = np.array([[-26, -25, -24, -23, -22, -20, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10], [-9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 9], [11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 22, 23, 24, 25, 26, 27]]) #-32 to +31
              #this is a test program where the subcarrier patterns and dimensions will be hard-coded
              i = -1
              run = True
              while (run and i < 2):
              	i = i+1
              	run = False
              	for j in range(0, 15):
              		if inp[0][(sc_lut[i][j])+32] < self.thold: #the difference here (vs power decision block 2) is we WANT to match the pattern
              			run = True
              # we found a successful pattern if run is false, otherwise none of the patterns worked and output a -1 (sus condition)
              if run:
              	i = -1
              self.message_port_pub(pmt.intern("pattern_out"), pmt.to_pmt(i))
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    thold: thold
    vlen: fft_len
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {state: disabled}
- name: header_bits
  id: virtual_sink
  parameters:
    stream_id: Header Bits
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.digital.utils import tagged_streams
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '1'
    fft_size: fft_len
    frame_rate: '1000'
    ref_scale: '0.00001'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    vlen: fft_len
    x_start: '-8'
    x_step: '1.0'
    ymax: '2000'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: fft_len
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: sonny_ofdma_ofdma_tx_0
  id: sonny_ofdma_ofdma_tx
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sc_tag_key: '"sc_tag_key"'
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '915000000'
    dev_addr: '"addr=192.168.10.2"'
    gain0: '0.5'
    gain_type0: normalized
    samp_rate: samp_rate
    stream_args: '"streamer=replay_buffered"'
    stream_chans: '[0]'
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '915000000'
    dev_addr: '"serial=3233202"'
    gain0: '0'
    samp_rate: samp_rate
    stream_chans: '1'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '915000000'
    clock_source0: internal
    dc_offs_enb0: auto
    dev_addr: '"serial = 3233202"'
    gain0: gain
    iq_imbal_enb0: auto
    samp_rate: samp_rate
    stream_chans: '0'
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload Bits
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_moving_average_xx_1, '0', epy_block_0_0, '0']
- [blocks_moving_average_xx_1_0, '0', epy_block_0_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_repack_bits_bb_0, '0', virtual_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_packet_headergenerator_bb_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_1, '0']
- [blocks_tag_gate_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_tag_gate_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_tag_gate_0, '0', uhd_usrp_sink_1, '0']
- [blocks_tagged_stream_mux_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_tag_gate_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', qtgui_time_sink_x_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', uhd_usrp_sink_0, '0']
- [digital_packet_headergenerator_bb_0, '0', header_bits, '0']
- [epy_block_0, '0', sonny_ofdma_ofdma_tx_0, '0']
- [epy_block_0_0, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_0_0_1, '0', qtgui_vector_sink_f_0_0, '0']
- [epy_block_0_0_1, pattern_out, blocks_message_strobe_0, set_msg]
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [logpwrfft_x_0, '0', blocks_moving_average_xx_1_0, '0']
- [sonny_ofdma_ofdma_tx_0, '0', fft_vxx_0, '0']
- [uhd_usrp_source_0_0_0, '0', logpwrfft_x_0, '0']
- [virtual_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [virtual_source_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_0_0_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
