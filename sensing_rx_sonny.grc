options:
  parameters:
    generate_options: qt_gui
    id: asssssss
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f
  id: variable_qtgui_range
  parameters:
    label: freq
    start: 914e6
    step: 100e3
    stop: 916e6
    value: 915e6
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: rf gain
    start: '-10'
    step: '1'
    stop: '100'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: subcarriers
  id: variable
  parameters:
    value: (list(range(-26,-21)) + list(range(-20,-9)), list(range(-9,-7)) + list(range(-6,0)) + list(range(1,7)) + list(range(8,10)), list(range(11,21)) + list(range(22,28)),)
  states: {}
- name: thold
  id: variable_qtgui_range
  parameters:
    label: Threshold
    min_len: '1000'
    rangeType: int
    start: '0'
    step: '1'
    stop: '800'
    value: '380'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("beep")
    period: '1000'
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: '10'
    scale: '0.3'
    type: float
    vlen: fft_len
  states: {state: disabled}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: '500'
    max_iter: '1000'
    scale: '0.02'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '3140000'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, vlen = 64, thold = 500):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Power Decision Block 2',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              self.vlen = vlen
              self.thold = thold
              self.message_port_register_out(pmt.intern("pattern_out"))
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              inp = np.array(input_items)
              inp = inp[0,:]
              sc_lut = np.array([[-26, -25, -24, -23, -22, -20, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10], [-9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 9], [11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 22, 23, 24, 25, 26, 27]]) #-32 to +31
              #this is a test program where the subcarrier patterns and dimensions will be hard-coded
              i = -1
              run = True
              while (run and i < 2):
              	i = i+1
              	run = False
              	for j in range(0, 15):
              		if inp[0][(sc_lut[i][j])+32] > self.thold:
              			run = True
              # we found a successful pattern if run is false, otherwise none of the patterns worked and just set it to pattern 0 anyways
              if run:
              	i = 0
              self.message_port_pub(pmt.intern("pattern_out"), pmt.to_pmt(i))
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    thold: thold
    vlen: fft_len
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, vlen = 64, thold = 500):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Power Decision Block',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              self.vlen = vlen
              self.thold = thold
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              #output_items[0][:] = input_items[0][:]
              #fuck you Python
              inp = np.array(input_items)
              inp = inp[0,:]
              oup = inp
              for i in range(self.vlen):
                  if inp[0][i] > self.thold:
                      oup[0][i] = 1000
                  else:
                      oup[0][i] = 0
              output_items[0][:] = oup[0][:]
              return len(output_items[0])
    thold: thold
    vlen: fft_len
  states: {state: disabled}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {state: disabled}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '1'
    fft_size: fft_len
    frame_rate: '1000'
    ref_scale: '0.00001'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '915000000'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: fft_len
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: f
    dev_addr: '"serial = 3233202"'
    gain0: '10'
    samp_rate: samp_rate
    stream_chans: '1'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '915000000'
    clock_source0: internal
    dc_offs_enb0: auto
    dev_addr: '"serial = 3233202"'
    gain0: gain
    iq_imbal_enb0: auto
    samp_rate: samp_rate
    stream_chans: '0'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_moving_average_xx_1, '0', epy_block_0_0, '0']
- [blocks_moving_average_xx_1_0, '0', epy_block_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_1, '0']
- [blocks_stream_to_vector_0, '0', logpwrfft_x_0, '0']
- [blocks_vco_c_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_0_0, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_0_0, pattern_out, blocks_message_strobe_0, set_msg]
- [fft_vxx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [logpwrfft_x_0, '0', blocks_moving_average_xx_1_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0_0, '0', logpwrfft_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
