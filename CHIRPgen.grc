options:
  parameters:
    generate_options: qt_gui
    id: CHIRPgen
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: B
  id: variable
  parameters:
    value: BT//T
  states: {}
- name: BT
  id: variable
  parameters:
    value: '100'
  states: {}
- name: N
  id: variable
  parameters:
    value: BT*OVS
  states: {}
- name: OVS
  id: variable
  parameters:
    value: '10'
  states: {}
- name: T
  id: variable
  parameters:
    value: '0.0005'
  states: {}
- name: fs
  id: variable
  parameters:
    value: B*OVS
  states: {}
- name: rf_tuning
  id: variable_qtgui_range
  parameters:
    label: tuning
    start: '902000000'
    step: '200000'
    stop: '928000000'
    value: '915000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: rx gain
    start: '0'
    step: '0.5'
    stop: '70'
    value: '20'
  states: {}
- name: tx_pwr
  id: variable_qtgui_range
  parameters:
    label: tx power
    start: '0'
    step: '0.01'
    stop: '10'
    value: '0.5'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /nfs/users/j149q328/Documents/CHIRPgen_re.txt
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /nfs/users/j149q328/Documents/CHIRPgen_im.txt
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: fs
    fc: rf_tuning
    fftsize: 2*N-1
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: N
    srate: fs
    type: complex
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: fs
    center_freq0: rf_tuning
    clock_rate: 125.0e6
    dev_addr: '"addr=192.168.10.2"'
    gain0: tx_pwr
    samp_rate: fs
    stream_chans: '[0]'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: fs
    center_freq0: rf_tuning
    dev_addr: '"addr=192.168.10.2"'
    gain0: rx_gain
    samp_rate: fs
    stream_chans: '[1]'
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_1, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
