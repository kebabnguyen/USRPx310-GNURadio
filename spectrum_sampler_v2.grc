options:
  parameters:
    generate_options: hb
    id: spectrum_sampler_v2
    output_language: python
    title: spectrum_simple
  states: {}

blocks:
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftlen
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    showports: 'True'
    type: float
    vlen: fftlen
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: fftlen
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftlen
    type: complex
  states: {}
- name: customblocka_togglewrite_filesink_0
  id: customblocka_togglewrite_filesink
  parameters:
    append: 'False'
    filename: filename
    type: float
    vlen: fftlen
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      import time

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """blah blah"""

          def __init__(self, vectorlength = 64):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              self.veclen = vectorlength
              gr.sync_block.__init__(
                  self,
                  name='Cycle Invert',   # will show up in GRC
                  in_sig=[(np.float32, self.veclen)],
                  out_sig=[(np.float32, self.veclen)]
                  
          
              )
              self.message_port_register_out(pmt.intern('toggle message'))
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.togglemsg = True
              self.counter = 0

          def work(self, input_items, output_items):
              self.counter = self.counter + len(output_items[0][:])
              print(self.counter)
              output_items[0][:] = input_items[0]
              if(self.counter > 96):
                  self.togglemsg = not self.togglemsg
                  #print(len(output_items[0][:]), output_items[0][:])
                  self.counter = 0
                  self.message_port_pub(pmt.intern('toggle message'), pmt.to_pmt(self.togglemsg))
                  time.sleep(5)
              
              
              return len(output_items[0])
    vectorlength: fftlen
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftlen
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftlen)
  states: {}
- name: fftlen
  id: parameter
  parameters:
    label: length_fft
    type: intx
    value: '64'
  states: {}
- name: filename
  id: parameter
  parameters:
    label: output_filename
    type: str
    value: ./copytest2.bin
  states: {}
- name: numsnaps
  id: parameter
  parameters:
    label: num_fftsamples
    type: intx
    value: '4'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: radio
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: thesauce
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: thesauce
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_copy_0, '0', customblocka_togglewrite_filesink_0, '0']
- [blocks_nlog10_ff_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', blocks_copy_0, '0']
- [epy_block_0, toggle message, blocks_copy_0, en]
- [epy_block_0, toggle message, customblocka_togglewrite_filesink_0, reset]
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
