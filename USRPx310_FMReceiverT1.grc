options:
  parameters:
    author: k822n167
    generate_options: qt_gui
    id: USRPx310_FMReceiver
    output_language: python
    title: FM_Receiver_Test
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: channel_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '-3000'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '88000000'
    step: '200000'
    stop: '108000000'
    value: '102100000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '.05'
    stop: '1'
    value: '.3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decim
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: '192000'
    deviation: deviation
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: SpecAn
    plotfreq: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: rf_decim
    interp: interp
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: '500000'
    center_freq0: tuning
    dc_offs_enb0: '""'
    dev_addr: '"addr=192.168.10.2"'
    gain0: '75'
    iq_imbal_enb0: '""'
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
